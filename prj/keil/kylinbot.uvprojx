# Keil uVision project kylinbot.uvprojx, settings and files
target kylinbot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kylinbot +hex
  AfterMake: fromelf.exe  --bin -o ../bin/kylinbot.bin ./Objects/kylinbot.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F427X,STM32F427xx
  c misc: --C99
  c include: ..\..\stl\CMSIS\core;..\..\stl\CMSIS\device;..\..\stl\StdPeriph_Driver\inc;..\..\stl\inc;..\..\bsp\inc;..\..\srv\inc;..\..\asp\inc;..\..\app\inc;..\..\usr\inc;..\..\kos\inc;..\..\drv\inc;..\..\stl\inc;..\..\hal\inc;..\..\rtx\inc;..\..\rtx\inc\arm
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usr/inc
    ../../usr/inc/: main.h stm32f4xx_it.h
  group usr/src
    ../../usr/src/: main.c stm32f4xx_it.c
  group kos/inc
    ../../kos/inc/: kos.h sch.h
  group kos/src
    ../../kos/src/: kos.c sch.c
  group app/inc
    ../../app/inc/: act.h app.h cal.h can.h cci.h cfg.h clk.h cmd.h com.h ctl.h dbg.h dci.h dnl.h fos.h hci.h ini.h ios.h mec.h odo.h pwr.h rci.h snd.h srs.h sys.h upd.h upl.h wdg.h wsm.h
  group app/src
    ../../app/src/: act.c app.c cal.c can.c cci.c cfg.c clk.c cmd.c com.c ctl.c dbg.c dci.c dnl.c fos.c hci.c ini.c ios.c mec.c odo.c pwr.c rci.c snd.c srs.c sys.c upd.c upl.c wdg.c wsm.c
  group asp/inc
    ../../asp/inc/: ahrs.h calib.h asp.h cbus.h crc16.h dbuf.h dbus.h ekf.h est.h fifo.h fun.h gdf.h hcf.h hcp.h linkedlist.h linkednode.h maf.h mecanum.h med.h msg.h pid.h rcf.h rcp.h rmp.h stack.h
  group asp/src
    ../../asp/src/: ahrs.c calib.c cbus.c crc16.c dbuf.c dbus.c ekf.c est.c fifo.c fun.c gdf.c hcf.c hcp.c linkedlist.c linkednode.c maf.c mecanum.c med.c msg.c pid.c rcf.c rcp.c rmp.c stack.c
  group srv/inc
    ../../srv/inc/: can_srv.h com_srv.h ext_srv.h rcv_srv.h srv.h tim_srv.h
  group srv/src
    ../../srv/src/: can_srv.c com_srv.c ext_srv.c rcv_srv.c srv.c tim_srv.c
  group bsp/inc
    ../../bsp/inc/: beep.h bsp.h btm.h btn.h can1.h can2.h dbi.h ist8310.h ist8310_drv.h ist8310_i2c.h ist8310_int.h key.h led.h mpu6500.h mpu6500_drv.h mpu6500_int.h mpu6500_spi.h platform.h pwm.h rcv.h spi5.h sr04.h stm32util.h tim.h tty.h
  group bsp/src
    ../../bsp/src/: beep.c bsp.c btm.c btn.c can1.c can2.c dbi.c ist8310.c ist8310_drv.c ist8310_i2c.c ist8310_int.c key.c led.c mpu6500.c mpu6500_drv.c mpu6500_int.c mpu6500_spi.c pwm.c rcv.c spi5.c sr04.c stm32util.c tim.c tty.c
  group drv/inc
    ../../drv/inc/: delay.h flash.h motor.h zgyro.h drv.h
  group drv/src
    ../../drv/src/: delay.c flash.c motor.c zgyro.c drv.c
  group hal/inc
    ../../hal/inc/: hal.h hal_gpio.h hal_sr04.h hal_uart.h
  group hal/src
    ../../hal/src/: hal.c hal_gpio.c hal_sr04.c hal_uart.c
  group stl/inc
    ../../stl/CMSIS/device/: stm32f4xx.h system_stm32f4xx.h
    ../../stl/StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_conf.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group stl/src
    ../../stl/StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmip2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../stl/src/: system_stm32f4xx.c
    ../../stl/src/arm/: startup_stm32f427xx.s
  group rtx/inc
    ../../rtx/inc/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../rtx/inc/arm/: portmacro.h
  group rtx/src
    ../../rtx/src/: croutine.c event_groups.c heap_2.c list.c queue.c tasks.c timers.c
    ../../rtx/src/arm/: port.c
